# Keil uVision project mr_j2s_a.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32E503RE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.3.2
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: mr_j2s_a +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E50X_HD GD32E50X
  c include: .\CMSIS\GD\GD32E50x\Include;.\GD32E50x_standard_peripheral\Include;.\CMSIS;.\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./src/: gd32e50x_it.c main.c mr_j2s_a_servo.c systick.c usart1_dma0.c timer.c
  group inc
    ./inc/: gd32e50x_it.h gd32e50x_libopt.h mr_j2s_a_servo.h systick.h usart1_dma0.h timer.h
  group cmsis
    ./CMSIS/GD/GD32E50x/Source/: system_gd32e50x.c
    ./CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32e50x_hd.s
  group device
    ./GD32E50x_standard_peripheral/Source/: gd32e50x_usart.c gd32e50x_gpio.c gd32e50x_dma.c gd32e50x_rcu.c gd32e50x_adc.c gd32e50x_bkp.c gd32e50x_can.c gd32e50x_cmp.c gd32e50x_crc.c gd32e50x_ctc.c gd32e50x_dac.c gd32e50x_dbg.c gd32e50x_enet.c gd32e50x_exmc.c gd32e50x_exti.c gd32e50x_fmc.c gd32e50x_fwdgt.c gd32e50x_i2c.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rtc.c gd32e50x_sdio.c gd32e50x_shrtimer.c gd32e50x_spi.c gd32e50x_sqpi.c gd32e50x_timer.c gd32e50x_tmu.c gd32e50x_wwdgt.c
software components: CMSIS:CORE 5.6.0
